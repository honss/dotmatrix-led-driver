# IAR project doom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EFM32ZG222F32
  ICCARM.CCIncludePath2: C:\Users\Aidan\Documents\efm32\inc; C:\Users\Aidan\Documents\efm32\Include; C:\Users\Aidan\Documents\efm32\src; C:\Users\Aidan\Documents\efm32\Gravity\inc; C:\Users\Aidan\Documents\efm32\Gravity\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: doom.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group em_device
    Include/: efm32zg108f32.h efm32zg108f4.h efm32zg108f8.h efm32zg110f16.h efm32zg110f32.h efm32zg110f4.h efm32zg110f8.h efm32zg210f16.h efm32zg210f32.h efm32zg210f4.h efm32zg210f8.h efm32zg222f16.h efm32zg222f32.h efm32zg222f4.h efm32zg222f8.h efm32zg_acmp.h efm32zg_adc.h efm32zg_aes.h efm32zg_af_pins.h efm32zg_af_ports.h efm32zg_calibrate.h efm32zg_cmu.h efm32zg_devinfo.h efm32zg_dma.h efm32zg_dma_ch.h efm32zg_dma_descriptor.h efm32zg_dmactrl.h efm32zg_dmareq.h efm32zg_emu.h efm32zg_gpio.h efm32zg_gpio_p.h efm32zg_i2c.h efm32zg_idac.h efm32zg_leuart.h efm32zg_msc.h efm32zg_pcnt.h efm32zg_prs.h efm32zg_prs_ch.h efm32zg_prs_signals.h efm32zg_rmu.h efm32zg_romtable.h efm32zg_rtc.h efm32zg_timer.h efm32zg_timer_cc.h efm32zg_usart.h efm32zg_vcmp.h efm32zg_wdog.h em_device.h system_efm32zg.h
  group incx
    inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_burtc.h em_bus.h em_can.h em_chip.h em_cmu.h em_common.h em_core.h em_cryotimer.h em_crypto.h em_csen.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_idac.h em_int.h em_lcd.h em_ldma.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_pcnt.h em_prs.h em_qspi.h em_ramfunc.h em_rmu.h em_rtc.h em_rtcc.h em_smu.h em_system.h em_timer.h em_usart.h em_vcmp.h em_vdac.h em_version.h em_wdog.h
  group main
    ./: bsp.c bsp.h main.c max7129.c startup_efm32.c system_efm32zg.c
    src/: em_dma.c
  group src
    src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_can.c em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_csen.c em_dac.c em_dbg.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_qspi.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_vdac.c em_wdog.c
